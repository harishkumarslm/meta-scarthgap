PACKAGECONFIG:append:at91sam9 = " gallium"
PACKAGECONFIG:append:sama5 = " gallium"
PACKAGECONFIG:append:rugged-board-a5d2x = " gallium"
PACKAGECONFIG:append:rugged-board-a5d2x-sd1 = " gallium"
