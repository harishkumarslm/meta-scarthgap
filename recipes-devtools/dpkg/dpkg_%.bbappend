EXTRA_OECONF += " --host=${DPKG_ARCH}"
PACKAGE_ARCH = "${MACHINE_ARCH}"
COMPATIBLE_MACHINE = "(rugged-board-a5d2x|rugged-board-a5d2x-sd1)"
