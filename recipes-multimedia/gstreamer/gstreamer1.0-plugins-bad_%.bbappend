# PACKAGECONFIG_remove = " directfb"
PACKAGECONFIG:remove = " vulkan"

